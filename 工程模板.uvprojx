# Keil uVision project 工程模板.uvprojx, settings and files
target 工程模板 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CW32F030C8 WHXY
  pack: WHXY.CW32F030_DFP.1.0.5
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 工程模板
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .;.\Driver;D:\51\cw32f030\KEIL5工程模板-CW32F030\Hardware;.\User
  memory RVCT4: ROM 0x0 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Driver
    ./Driver/: cw32f030_adc.c cw32f030_atim.c cw32f030_awt.c cw32f030_btim.c cw32f030_crc.c cw32f030_debug.c cw32f030_digitalsign.c cw32f030_dma.c cw32f030_flash.c cw32f030_gpio.c cw32f030_gtim.c cw32f030_i2c.c cw32f030_iwdt.c cw32f030_lvd.c cw32f030_pwr.c cw32f030_ram.c cw32f030_rcc.c cw32f030_rtc.c cw32f030_spi.c cw32f030_systick.c cw32f030_uart.c cw32f030_vc.c cw32f030_wwdt.c system_cw32f030.c startup_cw32f030.s
  group Hardware
    ./: GPIO.c GPIO.h TIM.c TIM.h Seg_Display.c Seg_Display.h ADC.c ADC.h Calibration.c Calibration.h
  group User
    ./User/: main.c interrupts_cw32f030.c
software components: CMSIS:CORE 5.6.0
